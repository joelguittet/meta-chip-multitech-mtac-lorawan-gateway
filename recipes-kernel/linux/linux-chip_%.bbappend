# Customization of linux-chip

# Version (can be retrieved with uname -a)
LINUX_KERNEL_TYPE = "lorawan-gateway"
